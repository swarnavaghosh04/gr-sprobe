options:
  parameters:
    author: Swarnava Ghosh
    generate_options: qt_gui
    id: example1
    output_language: python
    title: Gr-SProbe Example 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: start_tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("packet_len")
    offset: '0'
    src: pmt.PMT_F
    value: pmt.from_long(6)
  states: {}
- name: tag_along
  id: variable_tag_object
  parameters:
    key: pmt.intern("hello")
    offset: '2'
    src: pmt.PMT_F
    value: pmt.intern("test")
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[start_tag,tag_along]'
    type: float
    vector: (0, 1, 2, 3, 4, 5)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    name: '"Start"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '7'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    name: '"After Guard"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '7'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    name: '"After Unguard"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '7'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    name: '"After Buffer Filler"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '7'
  states: {}
- name: sprobe_guard_tagged_stream_x_0
  id: sprobe_guard_tagged_stream_x
  parameters:
    end_tag_key: packet_end
    in_type: float
    length_tag_key: packet_len
    tail_len: '3'
  states: {}
- name: sprobe_tagged_stream_buffer_filler_x_0
  id: sprobe_tagged_stream_buffer_filler_x
  parameters:
    buffer_len: '10'
    in_type: float
    length_tag_key: packet_len
  states: {}
- name: sprobe_unguard_tagged_stream_x_0
  id: sprobe_unguard_tagged_stream_x
  parameters:
    end_tag_name: packet_end
    in_type: float
    start_tag_name: packet_len
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', sprobe_guard_tagged_stream_x_0, '0']
- [sprobe_guard_tagged_stream_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [sprobe_guard_tagged_stream_x_0, '0', sprobe_unguard_tagged_stream_x_0, '0']
- [sprobe_tagged_stream_buffer_filler_x_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [sprobe_unguard_tagged_stream_x_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [sprobe_unguard_tagged_stream_x_0, '0', sprobe_tagged_stream_buffer_filler_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
